## zephyr_build/drivers/wifi/Kconfig
```kconfig
# Copyright (c) 2023 Beechwoods Software, Inc
# SPDX-License-Identifier: Apache-2.0

if WIFI
rsource "zephyr_cyw43/Kconfig"
endif # WIFI
```
